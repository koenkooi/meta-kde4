# Please note that this can break any eglibc build, for some unknown reason it can break native builds too.
BBCLASSEXTEND = "native"
