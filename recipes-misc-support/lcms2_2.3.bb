LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=6c786c3b7a4afbd3c990f1b81261d516"

SRC_URI = "http://freefr.dl.sourceforge.net/project/lcms/lcms/2.3/lcms2-2.3.tar.gz"
SRC_URI[md5sum] = "327348d67c979c88c2dec59a23a17d85"
SRC_URI[sha256sum] = "3ea177bbde947be5b9256b817d1cf98ab9c67c558b35703c48f5dbf8e0afafe4"

inherit autotools
