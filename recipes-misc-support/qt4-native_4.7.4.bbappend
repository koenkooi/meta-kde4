# Needed by kdelibs4-native
EXTRA_OECONF += "-no-pch -no-sm -openssl"

TOBUILD += "src/phonon"
