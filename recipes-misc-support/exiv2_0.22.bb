LICENSE = "GPLv2"
LIC_FILES_CHKSUM = "file://COPYING;md5=625f055f41728f84a8d7938acc35bdc2"

SRC_URI = "http://www.exiv2.org/exiv2-0.22.tar.gz"
SRC_URI[md5sum] = "84d7d5b1802529efca8ac3d6e6a97e3a"
SRC_URI[sha256sum] = "d338a5079a3d30e81b294b75cc16433794a0c06ccd71b07c524a46ec4826ce7a"

inherit autotools gettext
